Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-08-09T12:28:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - Alternate UI 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 09 12:28:46 2022 * Host: PC-043 * Database: C:\Users\PC-043\AppData\Local\Temp\693ce267-9e08-462e-947a-ceabd1b291a3\e5233876-5b17-49aa-815e-93e8e4a53efc\ifc * Database version: 5507 * Database creation date: Tue Aug 09 12:28:45 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 09 12:28:45 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 09 12:28:45 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: Pull Down Eyewash-Wall mounted :EL 487, Pull Down Eyewash-Wall mounted :EL 487:3782
In: Level 1
Type - Material: Chrome Plated
Type - Pset_BuildingElementProxyCommon - Reference: EL 487
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: EL 487
Material: Chrome Plated, Yellow
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_3782
Description: Flow; FlowDirection: SOURCEANDSINK
